# FIXME check to see if we are using system D .... also upstream has no version .... quility ...
FILES:${PN} += " ${systemd_system_unitdir}/cpupower.service"
